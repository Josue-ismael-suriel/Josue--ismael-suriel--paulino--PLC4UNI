# Repository Josue-ismael-suriel/Josue--ismael-suriel--paulino--PLC4UNI

## KiCad design diseños de kicad/12Board-PLC4UNI-G1W/12Board-PLC4UNI-G1W.kicad_pcb

Board: 2 copper layers, 100.0 x 80.2 mm, 111 parts (0 on the bottom side), 69 nets.

Parts:
C1: 100nF; C_0201_0603Metric
C2, C4: 0.1uF; C_0603_1608Metric
C3: 1uF; C_0603_1608Metric
C5, C8: 220pF; C_0805_2012Metric
C6, C7, C9, C10: 1uF; C_0805_2012Metric
C11: 10uF; C_1206_3216Metric
C12: 100nF; C_0805_2012Metric
C13, C14: 22uF; C_1206_3216Metric
D1: TVA; D_SOD-123F
D2, D10: D_Zener; D_0603_1608Metric
D3, D11: SMF24A; D_SMF
D5, D6: 1N4148WT; D_SOD-523
D7, D8, D9: M7; D_SMA
F1: Fuse; Fuse_1812_4532Metric
J6: PINHD_2x5_Male; PinHeader_2x05_P2.54mm_Horizontal
K1, K2: G5V-1; Relay_SPDT_Omron_G5V-1
L1: ANR4030T6R8M; L_APV_ANR4030
LED1: LED_0603_Red; LED_0603_1608Metric
OC1, OC2, OC3, OC4: TLP293; SOP-4_4.4x2.6mm_P1.27mm
Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q12, Q14: BC817; SOT-23
Q11, Q13, Q15: MMBT4403; SOT-23
R1, R2, R3, R31, R38, R40, R42, R43, R45, R47, R48, R50, R52, R53: 10k; R_0603_1608Metric
R6, R7, R13, R19, R20, R21, R25, R28, R32: 10K; R_0603_1608Metric
R8, R23: 4.7K; R_0603_1608Metric
R9, R22, R24, R27, R29, R34: 2.4K; R_0603_1608Metric
R12: 20K; R_0603_1608Metric
R14, R15, R41, R46, R51: 4.7k; R_0603_1608Metric
R16, R54: 2.5k; R_0603_1608Metric
R17, R55: 470k; R_0603_1608Metric
R18, R56: 15; R_0603_1608Metric
R26, R33: 47K; R_0603_1608Metric
R30, R35, R36, R37, R39, R44, R49: 2.4k; R_0603_1608Metric
R57: 1k; R_0603_1608Metric
U1: SP3485EN; SOIC-8_3.9x4.9mm_P1.27mm
U4: ESOP-8_L4.9-W3.9-P1.27-LS6.0-BL-EP
U5, U6: SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm
U7: AP63203WU; TSOT-23-6
U8: ESP32-S3-MINI-1U; ESP32-S2-MINI-1U
connector-up1, connector-up2, connector-up3, connector-up4: Screw_Terminal_9_P5.00mm; TerminalBlock_Phoenix_PT-1,5-9-5.0-H_1x09_P5.00mm_Horizontal

Connections:
+3.3V: C1.1, C13.1, C14.1, L1.2, R1.2, R7.1, R9.2, R14.1, R15.1, R20.1, R22.2, R24.2, R27.2, R29.2, R34.2, U1.8 (VCC), U7.1 (FB), U8.3 (3V3)
/Board-PLC4UNI-G1W/IN_NPN: Q4.1 (B), R28.2
/Board-PLC4UNI-G1W/IN_NPN2: Q2.1 (B), R21.2
/Board-PLC4UNI-G1W/Input_0-10V/ADC_IN_3V3: C2.2, R12.2, R13.1
/Board-PLC4UNI-G1W/Input_NPN1/OUT: Q2.3 (C), R22.1, U8.25 (IO21)
/Board-PLC4UNI-G1W/Input_NPN1_Opto1/OUT: OC1.4, R7.2, U8.32 (IO36)
/Board-PLC4UNI-G1W/Input_NPN1_Opto/OUT: OC3.4, R20.2, U8.31 (IO35)
/Board-PLC4UNI-G1W/Input_NPN/OUT: Q4.3 (C), R29.1, U8.26 (IO26)
/Board-PLC4UNI-G1W/Input_PNP1_Opto/OUT: OC4.4, R24.1, U8.28 (IO33)
/Board-PLC4UNI-G1W/Input_PNP2/OUT: Q3.3 (C), R27.1, U8.34 (IO38)
/Board-PLC4UNI-G1W/Input_PNP2_Opto/OUT: OC2.4, R9.1, U8.29 (IO34)
/Board-PLC4UNI-G1W/Input_PNP/OUT: Q6.3 (C), R34.1, U8.33 (IO37)
/Board-PLC4UNI-G1W/OutRelay2/IN: R36.1, U8.6 (IO2)
/Board-PLC4UNI-G1W/Out_0-10V: C4.2, D1.1 (K), U4.6 (VOUT)
/Board-PLC4UNI-G1W/OutputRelay1/IN: R35.1, U8.30 (IO48)
/Board-PLC4UNI-G1W/Output_0-10V/SCL: R14.2, U4.1 (SCLK), U5.1 (SCLK), U6.1 (SCLK), U8.13 (IO9)
/Board-PLC4UNI-G1W/Output_0-10V/SDA: R15.2, U4.2 (SDA), U5.2 (SDA), U6.2 (SDA), U8.12 (IO8)
/Board-PLC4UNI-G1W/Output_NPN1/IN: R30.1, U8.4 (IO0)
/Board-PLC4UNI-G1W/Output_NPN/IN: R37.1, U8.5 (IO1)
/Board-PLC4UNI-G1W/Output_PNP1/IN: R39.1, U8.38 (IO42)
/Board-PLC4UNI-G1W/Output_PNP2/IN: R49.1, U8.41 (IO45)
/Board-PLC4UNI-G1W/Output_PNP/IN: R44.1, U8.37 (IO41)
/Board-PLC4UNI-G1W/PLC4UNI/USB+: J6.9, U8.24 (USB_D+)
/Board-PLC4UNI-G1W/PLC4UNI/USB-: J6.7, U8.23 (USB_D-)
/Board-PLC4UNI-G1W/PLC4UNI/micro_rs485_rx: U1.4 (DI), U8.40 (RXD0)
/Board-PLC4UNI-G1W/PLC4UNI/micro_rs485_tx: U1.1 (RO), U8.39 (TXD0)
/Board-PLC4UNI-G1W/PNP_OUT1: D8.1 (K), Q13.3 (C), R48.2
/Board-PLC4UNI-G1W/PNP_OUT2: D7.1 (K), Q11.3 (C), R43.2
/Board-PLC4UNI-G1W/PNP_OUT3: D9.1 (K), Q15.3 (C), R53.2
/Board-PLC4UNI-G1W/RS485_Module1_protect/~TX/RX: U1.2 (~RE), U1.3 (DE)
/Board-PLC4UNI-G1W/con_RS485_A: R1.1, R2.2, U1.6 (A)
/Board-PLC4UNI-G1W/con_RS485_B: R2.1, R3.2, U1.7 (B)
/Board-PLC4UNI-G1W/out-common-1: K1.5, K1.6
/Board-PLC4UNI-G1W/out-common-2: K2.5, K2.6
GND: C1.2, C2.1, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, D1.2 (A), D3.2 (A2), D7.2 (A), D8.2 (A), D9.2 (A), D11.2 (A2), LED1.1 (K), OC1.3, OC2.2, OC2.3, OC3.3, OC4.2, OC4.3, Q2.2 (E), Q3.2 (E), Q4.2 (E), Q5.2 (E), Q6.2 (E), Q7.2 (E), Q8.2 (E), Q9.2 (E), Q10.2 (E), Q12.2 (E), Q14.2 (E), R3.1, R13.2, R16.2, R17.2, R26.2, R31.1, R33.2, R38.1, R40.1, R43.1, R45.1, R48.1, R50.1, R53.1, R54.2, R55.2, U1.5 (GND), U4.5 (GND), U4.9 (EP), U5.3 (A0), U5.4 (A1), U5.6 (GND), U5.9 (A2), U6.3 (A0), U6.4 (A1), U6.6 (GND), U6.9 (A2), U7.4 (GND), U8.1 (GND), U8.2 (GND), U8.42 (GND), U8.43 (GND), U8.46 (GND), U8.47 (GND), U8.48 (GND), U8.49 (GND), U8.50 (GND), U8.51 (GND), U8.52 (GND), U8.53 (GND), U8.54 (GND), U8.55 (GND), U8.56 (GND)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
unnamed: C7.1, D2.2 (A), R17.1
unnamed: D3.1 (A1), R18.2
unnamed: D5.2 (A), K1.9, Q7.3 (C)
unnamed: D6.2 (A), K2.9, Q8.3 (C)
unnamed: C10.1, D10.2 (A), R55.1
unnamed: D11.1 (A1), R56.2
unnamed: LED1.2 (A), R57.1
unnamed: OC1.1, R6.2
unnamed: OC2.1, R8.2
unnamed: OC3.1, R19.2
unnamed: OC4.1, R23.2
unnamed: Q3.1 (B), R25.1, R26.1
unnamed: Q5.1 (B), R30.2, R31.2
unnamed: Q6.1 (B), R32.1, R33.1
unnamed: Q7.1 (B), R35.2
unnamed: Q8.1 (B), R36.2
unnamed: Q9.1 (B), R37.2, R38.2
unnamed: Q10.1 (B), R39.2, R40.2
unnamed: Q10.3 (C), R41.1, R42.1
unnamed: Q11.1 (B), R42.2
unnamed: Q12.1 (B), R44.2, R45.2
unnamed: Q12.3 (C), R46.1, R47.1
unnamed: Q13.1 (B), R47.2
unnamed: Q14.1 (B), R49.2, R50.2
unnamed: Q14.3 (C), R51.1, R52.1
unnamed: Q15.1 (B), R52.2
unnamed: C3.1, U4.8 (V5V)
unnamed: C5.1, R16.1, U5.7 (SET)
unnamed: C6.1, U5.10 (V5V)
unnamed: C8.1, R54.1, U6.7 (SET)
unnamed: C9.1, U6.10 (V5V)
unnamed: C12.1, U7.6 (BST)
unnamed: C12.2, L1.1, U7.5 (SW)
VCC: C11.1, D2.1 (K), D5.1 (K), D6.1 (K), D10.1 (K), F1.2, K1.2, K2.2, Q11.2 (E), Q13.2 (E), Q15.2 (E), R6.1, R19.1, R21.1, R28.1, R41.2, R46.2, R51.2, R57.2, U4.4 (VCC), U5.5 (VCC), U6.5 (VCC), U7.2 (EN), U7.3 (IN)

## Commit log

2025-10-11 primer commit
2025-11-13 actualizacion de las tareas
2025-11-13 actu2
2025-11-13 actualizacion
2025-11-27 actualizacion 3
2025-11-27 actualizacion 5
2025-12-02 actualizacion 45
2025-12-03 actualizacion 47
2025-12-03 Actualizacion 48
2025-12-04 actualizacion 76
2025-12-11 actualizacion 234
2025-12-11 actualizacion 327
2025-12-11 actualizacion7667
2025-12-11 actualizacion23
